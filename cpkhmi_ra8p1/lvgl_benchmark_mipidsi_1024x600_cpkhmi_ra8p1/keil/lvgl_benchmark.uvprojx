# Keil uVision project lvgl_benchmark.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.6.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: lvgl_benchmark +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=4 v6LangP=6 wLevel=1
  c define: __PERFC_USE_PMU_PORTING__=1,__PERFC_CFG_DISABLE_DEFAULT_SYSTICK_PORTING__=1
  c misc: @./via/rasc_armclang.via
  c include: .\source;.\third
  asm misc: --via=./via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c lvgl_thread_entry.c
  group source
    ./source/: cm85_fault_handle.c console.c dave2d_cache_management.c i2c.c nor_flash.c touch.c usb_hid_code.c usb_thread.c
  group source/fusb303b
    ./source/fusb303b/: fusb303b.c
  group source/lcd
    ./source/lcd/: lcd.c lcd_ek79001.c lcd_ek79007ad2.c
  group source/utils
    ./source/utils/: log.c
  group third/perf_counter
    ./third/perf_counter/: perf_counter.c perfc_port_default.c perfc_port_pmu.c
  group third/SEGGER_RTT
    ./third/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
